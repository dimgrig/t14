# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; DEBUG=1
  ICCARM.CCIncludePath2: ; app\; board\; modules\; ..\..\STM32L1xx_StdPeriph_Lib\Libraries\STM32L1xx_StdPeriph_Driver\inc\; ..\..\STM32L1xx_StdPeriph_Lib\Libraries\CMSIS\CM3\CoreSupport\; ..\..\STM32L1xx_StdPeriph_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx\; ..\bsp\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32l1xx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; DEBUG=1; EMB_FLASH
  ICCARM.CCIncludePath2: ; app\; board\; modules\; ..\..\STM32L1xx_StdPeriph_Lib\Libraries\STM32L1xx_StdPeriph_Driver\inc\; ..\..\STM32L1xx_StdPeriph_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx\; ..\bsp\
  OBJCOPY.OOCOutputFile: GettingStarted.bin
  ILINK.IlinkIcfFile: config\stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __vector_table
  group (top)
    ./: AsciiLib.c AsciiLib.h GLCD.c GLCD.h GUI.c GUI.h main.c readme.txt stm32l1xx_conf.h t14-adc.c t14-adc.h t14-math.c t14-math.h t14-power.c t14-power.h t14-spi.c t14-spi.h t14-ssi.c t14-ssi.h t14-timer.c t14-timer.h TouchPanel.c TouchPanel.h
  group BSP
    ../bsp/: stm32.c
  group CMSIS
    ../../STM32L1xx_StdPeriph_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
    board/: system_stm32l1xx.c
  group Other
    config/: stm32l1xx_flash.icf stm32l1xx_ram.icf
  group StdPeriph_Driver
    ../../STM32L1xx_StdPeriph_Lib/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Vectors
    ./: stm32l1xx_it.c
